/*
 * Copyright (c) The mldsa-native project authors
 * SPDX-License-Identifier: Apache-2.0 OR ISC OR MIT
 */
#include "../../../common.h"

#if defined(MLD_ARITH_BACKEND_AARCH64) && !defined(MLD_CONFIG_NO_SIGN_API) && !defined(MLD_CONFIG_MULTILEVEL_NO_SHARED) &&  (defined(MLD_CONFIG_MULTILEVEL_WITH_SHARED) || (MLD_CONFIG_PARAMETER_SET == 65 || MLD_CONFIG_PARAMETER_SET == 87))
/* simpasm: header-end */

// a aliased with a0
.macro decompose32 a1, a, temp
        // range: 0 <= a <= Q-1 = 32*GAMMA2

        /* check-magic: 523776 == 2 * intdiv(MLDSA_Q - 1, 32) */
        /* check-magic: 1074791425 == floor(2**49 / 523776) */
        /* check-magic: 575897802350002176 == 1 / (1 / 523776 - 1074791425 / 2^49) */
        // Compute a1 = round-(a / (2*GAMMA2)) = round-(a / 523776) ≈
        // round(a * 1074791425 / 2^49), where round-() denotes "round half
        // down". This is exact for 0 <= a < Q. We'll prove this in the
        // following paragraphs, in which we denote 2*GAMMA2 as B to avoid
        // clutter.

        // Consider the (signed) error a * (1 / B - 1074791425 / 2^49) between
        // a / B and the (under-)approximation a * 1074791425 / 2^49. Because
        // eps := 1 / B - 1074791425 / 2^49 is 1 / 575897802350002176 ≈
        // 2^(-58.99) < 2^(-58), we have 0 <= a * eps < 2^23 * 2^(-58) =
        // 1 / 2^35 < 1 / 2^19 < 1 / B (note that a is non-negative).

        // On the other hand, 1 / B is the spacing between the integral
        // multiples of 1 / B, which includes all rounding boundaries n + 0.5
        // (since B is even). Hence, if a / B is not of the form n + 0.5, then
        // it is at least 1 / B away from the nearest rounding boundary, so
        // moving from a / B to a * 1074791425 / 2^49 does not affect the
        // rounding result, no matter the type of rounding used in either side.
        // In particular, we have round-(a / B) = round(a * 1074791425 / 2^49)
        // as claimed.

        // As for the remaining case where a / B _is_ of the form n + 0.5,
        // because a * 1074791425 / 2^49 is slightly but strictly below a / B =
        // n + 0.5 (note that a and thus the error a * eps cannot be 0 here), it
        // is always rounded down to n. More precisely, we have round-(a / B) =
        // round(a * 1074791425 / 2^49), where the round-down on the LHS is
        // essential, and on the RHS the type of rounding again does not matter.
        // This concludes the proof.

        // See proofs/isabelle/compress for a formalization of this argument.
        sqdmulh \a1\().4s, \a\().4s, barrett_const.4s
        srshr \a1\().4s, \a1\().4s, #18
        // range: 0 <= a1 <= 16

        // If a1 = 16, i.e. a > 31*GAMMA2, proceed as if a' = a - Q was
        // given instead. (For a = 31*GAMMA2 + 1 thus a' = -GAMMA2, we
        // still round it to 0 like other "wrapped around" cases.)

        // Check for wrap-around
        cmgt \temp\().4s, \a\().4s, q_bound.4s

        // Compute remainder a0
        mls \a\().4s, \a1\().4s, gamma2_2x.4s
        // range: -GAMMA2 < a0 <= GAMMA2

        // This holds since a1 = round-(a / (2*GAMMA2)) was computed exactly.

        // If wrap-around is required, set a1 = 0 and a0 -= 1
        bic \a1\().16b, \a1\().16b, \temp\().16b
        add \a\().4s, \a\().4s, \temp\().4s
        // range: 0 <= a1 <= 15, -GAMMA2 <= a0 <= GAMMA2
.endm

        /* Parameters */
        a1_ptr          .req x0     // Output polynomial with coefficients c1
        a0_ptr          .req x1     // Input/Output polynomial with coefficients c0

        count           .req x3

        /* Constant register assignments */
        q               .req v20    // Q = 8380417
        q_bound         .req v21    // 31*GAMMA2 = 8118528
        gamma2_2x       .req v22    // 2*GAMMA2 = 523776
        barrett_const   .req v23    // Barrett constant = 1074791425


.text
.global MLD_ASM_NAMESPACE(poly_decompose_32_aarch64_asm)
.balign 4
MLD_ASM_FN_SYMBOL(poly_decompose_32_aarch64_asm)
        // Load constants into SIMD registers
        movz w4, #57345
        movk w4, #127, lsl #16
        dup q.4s, w4

        movz w5, #0xe100
        movk w5, #0x7b, lsl #16
        dup q_bound.4s, w5

        movz w7, #0xfe00
        movk w7, #7, lsl #16
        dup gamma2_2x.4s, w7

        movz w11, #0x0401
        movk w11, #0x4010, lsl #16
        dup barrett_const.4s, w11

        mov count, #(64/4)

                                              // Instructions:    29
                                              // Expected cycles: 23
                                              // Expected IPC:    1.26
                                              //
                                              // Cycle bound:     23.0
                                              // IPC bound:       1.26
                                              //
                                              // Wall time:     0.58s
                                              // User time:     0.58s
                                              //
                                              // ----- cycle (expected) ------>
                                              // 0                        25
                                              // |------------------------|----
        ldr q0, [x1, #16]                     // *.............................
        ldr q17, [x1, #32]                    // *.............................
        ldr q2, [x1, #48]                     // .*............................
        ldr q26, [x1, #64]                    // .*............................
        ldr q16, [x1, #0]                     // ..*...........................
        ldr q18, [x1, #96]                    // ..*...........................
        cmgt v31.4S, v17.4S, v21.4S           // ....*.........................
        sqdmulh v3.4S, v17.4S, v23.4S         // ....*.........................
        cmgt v4.4S, v2.4S, v21.4S             // .....*........................
        cmgt v5.4S, v16.4S, v21.4S            // ......*.......................
        sqdmulh v19.4S, v16.4S, v23.4S        // ......*.......................
        sqdmulh v7.4S, v2.4S, v23.4S          // ........*.....................
        srshr v3.4S, v3.4S, #18               // .........*....................
        sqdmulh v24.4S, v26.4S, v23.4S        // ..........*...................
        srshr v27.4S, v19.4S, #18             // ...........*..................
        mls v17.4S, v3.4S, v22.4S             // .............*................
        srshr v29.4S, v7.4S, #18              // .............*................
        bic v6.16B, v3.16B, v31.16B           // ..............*...............
        bic v1.16B, v27.16B, v5.16B           // ...............*..............
        mls v16.4S, v27.4S, v22.4S            // ...............*..............
        str q6, [x0, #32]                     // ................*.............
        str q1, [x0], #4*16                   // .................*............
        mls v2.4S, v29.4S, v22.4S             // .................*............
        add v6.4S, v17.4S, v31.4S             // ..................*...........
        sqdmulh v3.4S, v18.4S, v23.4S         // ...................*..........
        str q6, [x1, #32]                     // ....................*.........
        add v20.4S, v16.4S, v5.4S             // ....................*.........
        str q20, [x1], #4*16                  // ......................*.......
        add v17.4S, v2.4S, v4.4S              // ......................*.......

                                               // ------ cycle (expected) ------>
                                               // 0                        25
                                               // |------------------------|-----
        // ldr q18, [x1, #32]                  // *..............................
        // ldr q26, [x1, #0]                   // ..*............................
        // sqdmulh v3.4S, v18.4S, v23.4S       // ....*..........................
        // sqdmulh v24.4S, v26.4S, v23.4S      // ......*........................
        // ldr q5, [x1, #48]                   // .*.............................
        // cmgt v6.4S, v18.4S, v21.4S          // ....*..........................
        // srshr v3.4S, v3.4S, #18             // .........*.....................
        // cmgt v2.4S, v26.4S, v21.4S          // ......*........................
        // sqdmulh v16.4S, v5.4S, v23.4S       // ........*......................
        // srshr v28.4S, v24.4S, #18           // ...........*...................
        // cmgt v4.4S, v5.4S, v21.4S           // .....*.........................
        // mls v18.4S, v3.4S, v22.4S           // .............*.................
        // bic v3.16B, v3.16B, v6.16B          // ..............*................
        // mls v26.4S, v28.4S, v22.4S          // ...............*...............
        // bic v19.16B, v28.16B, v2.16B        // ...............*...............
        // str q3, [x0, #32]                   // ................*..............
        // srshr v29.4S, v16.4S, #18           // .............*.................
        // str q19, [x0], #4*16                // .................*.............
        // add v3.4S, v18.4S, v6.4S            // ..................*............
        // ldr q18, [x1, #96]                  // ..*............................
        // mls v5.4S, v29.4S, v22.4S           // .................*.............
        // add v27.4S, v26.4S, v2.4S           // ....................*..........
        // ldr q26, [x1, #64]                  // .*.............................
        // ldr q0, [x1, #16]                   // *..............................
        // str q3, [x1, #32]                   // ....................*..........
        // sqdmulh v3.4S, v18.4S, v23.4S       // ...................*...........
        // str q27, [x1], #4*16                // ......................*........
        // add v17.4S, v5.4S, v4.4S            // ......................*........
        // sqdmulh v24.4S, v26.4S, v23.4S      // ..........*....................

        sub count, count, #2
poly_decompose_32_loop:
                                              // Instructions:    36
                                              // Expected cycles: 19
                                              // Expected IPC:    1.89
                                              //
                                              // Cycle bound:     19.0
                                              // IPC bound:       1.89
                                              //
                                              // Wall time:     30.48s
                                              // User time:     30.48s
                                              //
                                              // ----- cycle (expected) ------>
                                              // 0                        25
                                              // |------------------------|----
        cmgt v1.4S, v0.4S, v21.4S             // l.............................
        ldr q5, [x1, #48]                     // *.............................
        cmgt v6.4S, v18.4S, v21.4S            // .*............................
        sqdmulh v20.4S, v0.4S, v23.4S         // .l............................
        str q17, [x1, #-16]                   // ..l...........................
        srshr v3.4S, v3.4S, #18               // ..*...........................
        bic v7.16B, v29.16B, v4.16B           // ...l..........................
        cmgt v2.4S, v26.4S, v21.4S            // ...*..........................
        sqdmulh v16.4S, v5.4S, v23.4S         // ....*.........................
        srshr v28.4S, v24.4S, #18             // ....*.........................
        str q7, [x0, #-16]                    // .....l........................
        cmgt v4.4S, v5.4S, v21.4S             // .....*........................
        srshr v31.4S, v20.4S, #18             // ......l.......................
        mls v18.4S, v3.4S, v22.4S             // ......*.......................
        bic v3.16B, v3.16B, v6.16B            // .......*......................
        mls v26.4S, v28.4S, v22.4S            // ........*.....................
        bic v19.16B, v28.16B, v2.16B          // ........*.....................
        str q3, [x0, #32]                     // .........*....................
        srshr v29.4S, v16.4S, #18             // .........*....................
        str q19, [x0], #4*16                  // ..........*...................
        mls v0.4S, v31.4S, v22.4S             // ..........l...................
        bic v30.16B, v31.16B, v1.16B          // ...........l..................
        add v3.4S, v18.4S, v6.4S              // ............*.................
        ldr q18, [x1, #96]                    // ............e.................
        mls v5.4S, v29.4S, v22.4S             // .............*................
        str q30, [x0, #-112]                  // .............l................
        add v27.4S, v26.4S, v2.4S             // ..............*...............
        ldr q26, [x1, #64]                    // ..............e...............
        add v25.4S, v0.4S, v1.4S              // ...............l..............
        ldr q0, [x1, #16]                     // ...............*..............
        str q3, [x1, #32]                     // ................*.............
        sqdmulh v3.4S, v18.4S, v23.4S         // ................e.............
        str q25, [x1, #-48]                   // .................l............
        str q27, [x1], #4*16                  // .................*............
        add v17.4S, v5.4S, v4.4S              // ..................*...........
        sqdmulh v24.4S, v26.4S, v23.4S        // ..................e...........

                                             // ------------ cycle (expected) ------------->
                                             // 0                        25
                                             // |------------------------|------------------
        // ldr q0, [x1, #0*16]               // ..e....'.............~....'.............~...
        // ldr q1, [x1, #1*16]               // ...~...'..............*...'..............~..
        // ldr q2, [x1, #2*16]               // e......'...........~......'...........~.....
        // ldr q3, [x1, #3*16]               // .......*..................~.................
        // sqdmulh v5.4s, v1.4s, v23.4s      // .......'~.................'l................
        // srshr v5.4s, v5.4s, #18           // .......'.....~............'.....l...........
        // cmgt v24.4s, v1.4s, v21.4s        // .......~..................l.................
        // mls v1.4s, v5.4s, v22.4s          // .......'.........~........'.........l.......
        // bic v5.16b, v5.16b, v24.16b       // .......'..........~.......'..........l......
        // add v1.4s, v1.4s, v24.4s          // ...~...'..............~...'..............l..
        // sqdmulh v6.4s, v2.4s, v23.4s      // ....e..'...............~..'...............~.
        // srshr v6.4s, v6.4s, #18           // .......'.*................'.~...............
        // cmgt v24.4s, v2.4s, v21.4s        // .......'*.................'~................
        // mls v2.4s, v6.4s, v22.4s          // .......'.....*............'.....~...........
        // bic v6.16b, v6.16b, v24.16b       // .......'......*...........'......~..........
        // add v2.4s, v2.4s, v24.4s          // ~......'...........*......'...........~.....
        // sqdmulh v7.4s, v3.4s, v23.4s      // .......'...*..............'...~.............
        // srshr v7.4s, v7.4s, #18           // .......'........*.........'........~........
        // cmgt v24.4s, v3.4s, v21.4s        // .......'....*.............'....~............
        // mls v3.4s, v7.4s, v22.4s          // .~.....'............*.....'............~....
        // bic v7.16b, v7.16b, v24.16b       // .......'..~...............'..l..............
        // add v3.4s, v3.4s, v24.4s          // ......~'.................*'.................
        // sqdmulh v4.4s, v0.4s, v23.4s      // ......e'.................~'.................
        // srshr v4.4s, v4.4s, #18           // .......'...*..............'...~.............
        // cmgt v24.4s, v0.4s, v21.4s        // .......'..*...............'..~..............
        // mls v0.4s, v4.4s, v22.4s          // .......'.......*..........'.......~.........
        // bic v4.16b, v4.16b, v24.16b       // .......'.......*..........'.......~.........
        // add v0.4s, v0.4s, v24.4s          // ..~....'.............*....'.............~...
        // str q5, [x0, #1*16]               // .~.....'............~.....'............l....
        // str q6, [x0, #2*16]               // .......'........*.........'........~........
        // str q7, [x0, #3*16]               // .......'....~.............'....l............
        // str q4, [x0], #4*16               // .......'.........*........'.........~.......
        // str q1, [x1, #1*16]               // .....~.'................~.'................l
        // str q2, [x1, #2*16]               // ....~..'...............*..'...............~.
        // str q3, [x1, #3*16]               // .......'.~................'.l...............
        // str q0, [x1], #4*16               // .....~.'................*.'.................

        subs count, count, #1
        bne poly_decompose_32_loop
                                              // Instructions:    43
                                              // Expected cycles: 24
                                              // Expected IPC:    1.79
                                              //
                                              // Cycle bound:     24.0
                                              // IPC bound:       1.79
                                              //
                                              // Wall time:     2.41s
                                              // User time:     2.41s
                                              //
                                              // ----- cycle (expected) ------>
                                              // 0                        25
                                              // |------------------------|----
        ldr q16, [x1, #48]                    // *.............................
        ldr q5, [x1, #16]                     // *.............................
        sqdmulh v28.4S, v0.4S, v23.4S         // .*............................
        cmgt v19.4S, v26.4S, v21.4S           // .*............................
        cmgt v2.4S, v0.4S, v21.4S             // ..*...........................
        str q17, [x1, #-16]                   // ..*...........................
        srshr v31.4S, v3.4S, #18              // ...*..........................
        sqdmulh v1.4S, v5.4S, v23.4S          // ....*.........................
        cmgt v6.4S, v16.4S, v21.4S            // ....*.........................
        srshr v24.4S, v24.4S, #18             // .....*........................
        srshr v25.4S, v28.4S, #18             // ......*.......................
        sqdmulh v20.4S, v16.4S, v23.4S        // ......*.......................
        cmgt v17.4S, v18.4S, v21.4S           // .......*......................
        mls v18.4S, v31.4S, v22.4S            // ........*.....................
        cmgt v27.4S, v5.4S, v21.4S            // ........*.....................
        srshr v30.4S, v1.4S, #18              // .........*....................
        mls v0.4S, v25.4S, v22.4S             // ..........*...................
        bic v28.16B, v25.16B, v2.16B          // ..........*...................
        srshr v7.4S, v20.4S, #18              // ...........*..................
        bic v25.16B, v24.16B, v19.16B         // ............*.................
        mls v26.4S, v24.4S, v22.4S            // ............*.................
        bic v20.16B, v30.16B, v27.16B         // .............*................
        str q28, [x0, #-48]                   // .............*................
        add v3.4S, v18.4S, v17.4S             // ..............*...............
        mls v5.4S, v30.4S, v22.4S             // ..............*...............
        str q20, [x0, #16]                    // ...............*..............
        bic v28.16B, v7.16B, v6.16B           // ...............*..............
        mls v16.4S, v7.4S, v22.4S             // ................*.............
        str q3, [x1, #32]                     // ................*.............
        str q28, [x0, #48]                    // .................*............
        add v3.4S, v0.4S, v2.4S               // .................*............
        bic v7.16B, v29.16B, v4.16B           // ..................*...........
        str q25, [x0], #4*16                  // ..................*...........
        str q3, [x1, #-48]                    // ...................*..........
        add v24.4S, v5.4S, v27.4S             // ...................*..........
        str q7, [x0, #-80]                    // ....................*.........
        add v19.4S, v26.4S, v19.4S            // ....................*.........
        add v25.4S, v16.4S, v6.4S             // .....................*........
        bic v6.16B, v31.16B, v17.16B          // .....................*........
        str q24, [x1, #16]                    // ......................*.......
        str q19, [x1], #4*16                  // ......................*.......
        str q6, [x0, #-32]                    // .......................*......
        str q25, [x1, #-16]                   // .......................*......

                                              // ------ cycle (expected) ------>
                                              // 0                        25
                                              // |------------------------|-----
        // cmgt v1.4S, v0.4S, v21.4S          // ..*............................
        // ldr q5, [x1, #48]                  // *..............................
        // cmgt v6.4S, v18.4S, v21.4S         // .......*.......................
        // sqdmulh v20.4S, v0.4S, v23.4S      // .*.............................
        // str q17, [x1, #-16]                // ..*............................
        // srshr v3.4S, v3.4S, #18            // ...*...........................
        // bic v7.16B, v29.16B, v4.16B        // ..................*............
        // cmgt v2.4S, v26.4S, v21.4S         // .*.............................
        // sqdmulh v16.4S, v5.4S, v23.4S      // ......*........................
        // srshr v28.4S, v24.4S, #18          // .....*.........................
        // str q7, [x0, #-16]                 // ....................*..........
        // cmgt v4.4S, v5.4S, v21.4S          // ....*..........................
        // srshr v31.4S, v20.4S, #18          // ......*........................
        // mls v18.4S, v3.4S, v22.4S          // ........*......................
        // bic v3.16B, v3.16B, v6.16B         // .....................*.........
        // mls v26.4S, v28.4S, v22.4S         // ............*..................
        // bic v19.16B, v28.16B, v2.16B       // ............*..................
        // str q3, [x0, #32]                  // .......................*.......
        // srshr v29.4S, v16.4S, #18          // ...........*...................
        // str q19, [x0], #4*16               // ..................*............
        // mls v0.4S, v31.4S, v22.4S          // ..........*....................
        // bic v30.16B, v31.16B, v1.16B       // ..........*....................
        // add v3.4S, v18.4S, v6.4S           // ..............*................
        // mls v5.4S, v29.4S, v22.4S          // ................*..............
        // str q30, [x0, #-112]               // .............*.................
        // add v27.4S, v26.4S, v2.4S          // ....................*..........
        // add v25.4S, v0.4S, v1.4S           // .................*.............
        // ldr q0, [x1, #16]                  // *..............................
        // str q3, [x1, #32]                  // ................*..............
        // str q25, [x1, #-48]                // ...................*...........
        // str q27, [x1], #4*16               // ......................*........
        // add v17.4S, v5.4S, v4.4S           // .....................*.........
        // cmgt v1.4S, v0.4S, v21.4S          // ........*......................
        // sqdmulh v20.4S, v0.4S, v23.4S      // ....*..........................
        // str q17, [x1, #-16]                // .......................*.......
        // bic v7.16B, v29.16B, v4.16B        // ...............*...............
        // str q7, [x0, #-16]                 // .................*.............
        // srshr v31.4S, v20.4S, #18          // .........*.....................
        // mls v0.4S, v31.4S, v22.4S          // ..............*................
        // bic v30.16B, v31.16B, v1.16B       // .............*.................
        // str q30, [x0, #-48]                // ...............*...............
        // add v25.4S, v0.4S, v1.4S           // ...................*...........
        // str q25, [x1, #-48]                // ......................*........


        ret

        .unreq a1_ptr
        .unreq a0_ptr
        .unreq count
        .unreq q
        .unreq q_bound
        .unreq gamma2_2x
        .unreq barrett_const
/* simpasm: footer-start */
#endif /* MLD_ARITH_BACKEND_AARCH64 && !MLD_CONFIG_NO_SIGN_API && \
          !MLD_CONFIG_MULTILEVEL_NO_SHARED && \
          (MLD_CONFIG_MULTILEVEL_WITH_SHARED || MLD_CONFIG_PARAMETER_SET == 65 \
          || MLD_CONFIG_PARAMETER_SET == 87) */
